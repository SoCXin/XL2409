# Keil uVision project Demo.uvprojx, settings and files
target XL2409_RX (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: PY32F030x8 Puya
  pack: Puya.PY32F0xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,PY32F030x8
  c include: ..\Drivers\CMSIS\Device\PY32F0xx\Include;..\Drivers\CMSIS\Include;..\Drivers\PY32F0xx_HAL_Driver\Inc;..\User\Inc;..\User_Drivers\System_Clock_Config;..\User_Drivers\USART1;..\XL2400P_Drivers\RF;..\XL2400P_Drivers\SPI;..\XL2400P_Drivers\Delay;..\User_Drivers\LED;..\User_Drivers\User_Timer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group StartUP
    ../Drivers/CMSIS/Device/PY32F0xx/Source/: system_py32f0xx.c
    ../Drivers/CMSIS/Device/PY32F0xx/Source/arm/: startup_py32f030x8.s
  group PY_Dricers
    ../Drivers/PY32F0xx_HAL_Driver/Src/: py32f0xx_hal.c py32f0xx_hal_adc.c py32f0xx_hal_adc_ex.c py32f0xx_hal_comp.c py32f0xx_hal_cortex.c py32f0xx_hal_crc.c py32f0xx_hal_dma.c py32f0xx_hal_exti.c py32f0xx_hal_flash.c py32f0xx_hal_gpio.c py32f0xx_hal_i2c.c py32f0xx_hal_irda.c py32f0xx_hal_iwdg.c py32f0xx_hal_led.c py32f0xx_hal_lptim.c py32f0xx_hal_pwr.c py32f0xx_hal_rcc.c py32f0xx_hal_rcc_ex.c py32f0xx_hal_rtc.c py32f0xx_hal_rtc_ex.c py32f0xx_hal_spi.c py32f0xx_hal_tim.c py32f0xx_hal_tim_ex.c py32f0xx_hal_uart.c py32f0xx_hal_usart.c py32f0xx_hal_wwdg.c
  group User
    ../User/Src/: main.c py32f0xx_it.c
  group User_Drivers
    ../User_Drivers/LED/: LED.c
    ../User_Drivers/System_Clock_Config/: System_Clock_Config.c
    ../User_Drivers/USART1/: Usart1.c
    ../User_Drivers/User_Timer/: User_Timer.c
  group RF
    ../XL2400P_Drivers/SPI/: RF_SPI.c
    ../XL2400P_Drivers/RF/: RF.c
    ../XL2400P_Drivers/Delay/: RF_Delay.c
