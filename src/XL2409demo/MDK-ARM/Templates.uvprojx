# Keil uVision project Templates.uvprojx, settings and files
target SIP_MCU_Templates (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: ARM32F003x6 ARMM0
  pack: ARMM0.ARM32F0xx_DFP.0.0.6
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: SIP_MCU_Templates +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\MDK-ARM;..\Inc;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\XL32F003\Include;..\Drivers\sip_mcu_HAL_Driver\Inc;..\Drivers\sip_mcu_HAL_Driver\Src;..\Drivers\BSP;..\Drivers\XL32F003_HAL_Driver\Inc;..\Inc;..\MDK-ARM;..\Drivers\CMSIS\Include;..\Drivers\XL32F00x_HAL_Driver\Inc;..\Drivers\CMSIS\Device\XL32F003\Include;..\..\..\..\..\..\..\..\Desktop\学习资料\XL32F003开发包_1101\XL32F003开发包_1101\XL32F003开发包\XL32F0xx_LL_Firmware_V1.1.0\Drivers\XL32F0xx_HAL_Driver\Inc;..\..\..\..\..\..\..\..\Desktop\学习资料\XL32F003开发包_1101\XL32F003开发包_1101\XL32F003开发包\XL32F0xx_LL_Firmware_V1.1.0\Drivers\XL32F0xx_HAL_Driver\Src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Common
    ../Drivers/CMSIS/Device/XL32F003/Source/: system_xl_rf_sip.c
    ../Drivers/CMSIS/Device/XL32F003/Source/ARM/: startup_xl_rf_sip.s
  group Application/User
    ../Src/: main.c sip_mcu_hal_msp.c sip_mcu_it.c XL2400.c
  group Drivers/sip_mcu_HAL_Driver
    ../Drivers/XL32F00x_HAL_Driver/Src/: sip_mcu_hal.c sip_mcu_hal_adc.c sip_mcu_hal_adc_ex.c sip_mcu_hal_comp.c sip_mcu_hal_cortex.c sip_mcu_hal_crc.c sip_mcu_hal_dma.c sip_mcu_hal_exti.c sip_mcu_hal_flash.c sip_mcu_hal_gpio.c sip_mcu_hal_i2c.c sip_mcu_hal_irda.c sip_mcu_hal_iwdg.c sip_mcu_hal_led.c sip_mcu_hal_lptim.c sip_mcu_hal_pwr.c sip_mcu_hal_rcc.c sip_mcu_hal_rcc_ex.c sip_mcu_hal_rtc.c sip_mcu_hal_rtc_ex.c sip_mcu_hal_spi.c sip_mcu_hal_tim.c sip_mcu_hal_tim_ex.c sip_mcu_hal_uart.c sip_mcu_hal_usart.c sip_mcu_hal_wwdg.c
  group BSP
    ../Drivers/BSP/: bsp_encode.c bsp_expand.c bsp_flash.c bsp_iwdg.c bsp_key.c bsp_keyslisten.c bsp_led.c bsp_pins.c bsp_rf.c bsp_state_machine.c bsp_system.c bsp_tim3.c bsp_uart.c rf_test.c
