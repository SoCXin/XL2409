# Keil uVision project Project.uvprojx, settings and files
target Target (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARM32F003x6 ARMM0
  pack: ARMM0.ARM32F0xx_DFP.0.0.6
  cpu: CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Target +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: XL32F003x6,USE_FULL_LL_DRIVER
  c include: ..\..\..\..\..\..\Drivers\CMSIS\Include;..\Inc;..\..\..\..\..\..\Drivers\XL32F0xx_HAL_Driver;..\..\..\..\..\..\Drivers\CMSIS\Device\XL32F0xx;..\..\..\..\..\..\Drivers\BSP\XL32F003xx_Start_Kit;..\..\..\..\..\..\Drivers\XL32F0xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\XL32F0xx_HAL_Driver\Src;..\..\..\..\..\..\Drivers\CMSIS\Device\XL32F0xx\Include
  library: MicroLIB
  group Common
    ../../../../../../Drivers/CMSIS/Device/XL32F0xx/Source/: system_xl32f0xx.c
    ../../../../../../Drivers/CMSIS/Device/XL32F0xx/Source/arm/: startup_xl32f003x6.s
  group Application/User
    ../Src/: main.c xl32f0xx_it.c
  group Doc
    ../: readme.txt
  group BSP\XL32F003xx_Start_Kit
    ../../../../../../Drivers/BSP/XL32F003xx_Start_Kit/: xl32f003xx_ll_Start_Kit.c
  group Drivers\XL32F0xx_HAL_Driver
    ../../../../../../Drivers/XL32F0xx_HAL_Driver/Src/: xl32f0xx_ll_utils.c xl32f0xx_ll_gpio.c xl32f0xx_ll_rcc.c xl32f0xx_ll_exti.c xl32f0xx_ll_pwr.c xl32f0xx_ll_led.c
